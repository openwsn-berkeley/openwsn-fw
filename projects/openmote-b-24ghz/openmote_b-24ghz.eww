<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01bsp_leds\01bsp_leds.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_quick_cal\01bsp_quick_cal.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio\01bsp_radio.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio_rx\01bsp_radio_rx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio_tx\01bsp_radio_tx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_sctimer\01bsp_sctimer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_uart\01bsp_uart.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\02drv_openserial\02drv_openserial.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\02drv_opentimers\02drv_opentimers.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03oos_macpong\03oos_macpong.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03oos_mercator\03oos_mercator.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03oos_openwsn\03oos_openwsn.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03oos_sniffer\03oos_sniffer.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all_debug</name>
            <member>
                <project>01bsp_sctimer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>02drv_opentimers</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_macpong</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_openwsn</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_sniffer</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
