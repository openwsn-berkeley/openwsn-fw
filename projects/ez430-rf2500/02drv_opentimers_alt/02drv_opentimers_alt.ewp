# IAR project 02drv_opentimers_alt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\openwsn; ..\..\..\drivers\common; ..\..\..\bsp\boards; ..\..\..\bsp\boards\ez430-rf2500; ..\..\..\bsp\chips
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/02drv_opentimers/: 02drv_opentimers.c
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h sctimer.h uart.h
  group bsp/boards/common
    ../../../bsp/boards/common/: abstimer.c
  group bsp/boards/ez430-rf2500
    ../../../bsp/boards/ez430-rf2500/: board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c sctimer.c spi.c uart.c
  group drivers
    ../../../drivers/common/: opentimers.c opentimers.h
