<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_radio\01bsp_radio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_radio_rx\01bsp_radio_rx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_radio_tx\01bsp_radio_tx.ewp</path>
  </project>
  <batchBuild/>
</workspace>


