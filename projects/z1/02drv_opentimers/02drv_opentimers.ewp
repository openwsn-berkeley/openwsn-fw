# IAR project 02drv_opentimers.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2617 MSP430F2617
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\; ..\..\..\bsp\boards\z1\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\drivers\common\; ..\..\..\openstack\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/02drv_opentimers/: 02drv_opentimers.c
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/z1
    ../../../bsp/boards/z1/: board.c board_info.h bsp_timer.c debugpins.c eui64.c i2c.c leds.c radiotimer.c sctimer.c spi.c uart.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.h radio.c
  group drivers
    ../../../drivers/common/: opentimers.c opentimers.h
