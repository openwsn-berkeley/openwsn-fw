# IAR project 03oos_macpong.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\gina\; ..\..\..\drivers\common\; ..\..\..\drivers\gina\; ..\..\..\kernel\openos\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openapps\; ..\..\..\openapps\heli\; ..\..\..\openapps\imu\; ..\..\..\openapps\layerdebug\; ..\..\..\openapps\ohlone\; ..\..\..\openapps\rex\; ..\..\..\openapps\r6t\; ..\..\..\openapps\rheli\; ..\..\..\openapps\rinfo\; ..\..\..\openapps\rleds\; ..\..\..\openapps\rreg\; ..\..\..\openapps\rrube\; ..\..\..\openapps\rt\; ..\..\..\openapps\rrt\; ..\..\..\openapps\rwellknown\; ..\..\..\openapps\rxl1\; ..\..\..\openapps\tcpecho\; ..\..\..\openapps\tcpinject\; ..\..\..\openapps\tcpprint\; ..\..\..\openapps\udpecho\; ..\..\..\openapps\udpinject\; ..\..\..\openapps\udplatency\; ..\..\..\openapps\udpprint\; ..\..\..\openapps\udprand\; ..\..\..\openapps\udpstorm\; ..\..\..\openstack\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_macpong/: 03oos_macpong.c 03oos_macpong.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/gina
    ../../../bsp/boards/gina/: board.c board_info.h bsp_timer.c debugpins.c eui64.c i2c.c leds.c radiotimer.c spi.c uart.c
    ../../../drivers/gina/: gyro.c gyro.h large_range_accel.c large_range_accel.h magnetometer.c magnetometer.h sensitive_accel_temperature.c sensitive_accel_temperature.h
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group drivers/gina
    ../../../drivers/gina/: ADC_Channel.c ADC_Channel.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h processIE.c processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
