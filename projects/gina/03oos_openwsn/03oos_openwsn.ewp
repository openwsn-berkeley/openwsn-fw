# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\gina\; ..\..\..\drivers\common\; ..\..\..\drivers\gina\; ..\..\..\openstack\; ..\..\..\kernel\openos\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openapps\; ..\..\..\openapps\heli\; ..\..\..\openapps\imu\; ..\..\..\openapps\layerdebug\; ..\..\..\openapps\ohlone\; ..\..\..\openapps\rex\; ..\..\..\openapps\rheli\; ..\..\..\openapps\rinfo\; ..\..\..\openapps\rleds\; ..\..\..\openapps\rreg\; ..\..\..\openapps\rrube\; ..\..\..\openapps\r6t\; ..\..\..\openapps\rt\; ..\..\..\openapps\rrt\; ..\..\..\openapps\rwellknown\; ..\..\..\openapps\rxl1\; ..\..\..\openapps\tcpecho\; ..\..\..\openapps\tcpinject\; ..\..\..\openapps\tcpprint\; ..\..\..\openapps\udpecho\; ..\..\..\openapps\udpinject\; ..\..\..\openapps\udplatency\; ..\..\..\openapps\udpprint\; ..\..\..\openapps\udprand\; ..\..\..\openapps\udpstorm\; ..\..\..\openstack\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/gina
    ../../../bsp/boards/gina/: board.c board_info.h bsp_timer.c debugpins.c eui64.c i2c.c leds.c radiotimer.c spi.c uart.c
    ../../../drivers/gina/: gyro.c gyro.h large_range_accel.c large_range_accel.h magnetometer.c magnetometer.h sensitive_accel_temperature.c sensitive_accel_temperature.h
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group drivers/gina
    ../../../drivers/gina/: ADC_Channel.c ADC_Channel.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../../openstack/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openwsn/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h sixtop.c sixtop.h processIE.c processIE.h schedule.c schedule.h
  group openwsn/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openwsn/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openwsn/04-TRAN
    ../../../openstack/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group openwsn/07-App/heli
    ../../../openapps/heli/: heli.c heli.h
  group openwsn/07-App/imu
    ../../../openapps/imu/: imu.c imu.h
  group openwsn/07-App/layerdebug
    ../../../openapps/layerdebug/: layerdebug.c layerdebug.h
  group openwsn/07-App/ohlone
    ../../../openapps/ohlone/: ohlone.c ohlone.h ohlone_webpages.c ohlone_webpages.h
  group openwsn/07-App/r6t
    ../../../openapps/r6t/: r6t.c r6t.h
  group openwsn/07-App/rex
    ../../../openapps/rex/: rex.c rex.h
  group openwsn/07-App/rheli
    ../../../openapps/rheli/: rheli.c rheli.h
  group openwsn/07-App/rinfo
    ../../../openapps/rinfo/: rinfo.c rinfo.h
  group openwsn/07-App/rleds
    ../../../openapps/rleds/: rleds.c rleds.h
  group openwsn/07-App/rreg
    ../../../openapps/rreg/: rreg.c rreg.h
  group openwsn/07-App/rrt
    ../../../openapps/rrt/: rrt.c rrt.h
  group openwsn/07-App/rrube
    ../../../openapps/rrube/: rrube.c rrube.h
  group openwsn/07-App/rt
    ../../../openapps/rt/: rt.c rt.h
  group openwsn/07-App/rwellknown
    ../../../openapps/rwellknown/: rwellknown.c rwellknown.h
  group openwsn/07-App/rxl1
    ../../../openapps/rxl1/: rxl1.c rxl1.h
  group openwsn/07-App/tcpecho
    ../../../openapps/tcpecho/: tcpecho.c tcpecho.h
  group openwsn/07-App/tcpinject
    ../../../openapps/tcpinject/: tcpinject.c tcpinject.h
  group openwsn/07-App/tcpprint
    ../../../openapps/tcpprint/: tcpprint.c tcpprint.h
  group openwsn/07-App/udpecho
    ../../../openapps/udpecho/: udpecho.c udpecho.h
  group openwsn/07-App/udpinject
    ../../../openapps/udpinject/: udpinject.c udpinject.h
  group openwsn/07-App/udplatency
    ../../../openapps/udplatency/: udplatency.c udplatency.h
  group openwsn/07-App/udpprint
    ../../../openapps/udpprint/: udpprint.c udpprint.h
  group openwsn/07-App/udprand
    ../../../openapps/udprand/: udprand.c udprand.h
  group openwsn/07-App/udpstorm
    ../../../openapps/udpstorm/: udpstorm.c udpstorm.h
  group openwsn/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
