<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\00std_spi\00std_spi.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all_debug</name>
            <member>
                <project>01bsp_sctimer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>02drv_opentimers</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_macpong</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_openwsn</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>03oos_sniffer</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
