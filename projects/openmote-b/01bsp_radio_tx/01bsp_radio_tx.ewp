# IAR project 01bsp_radio_tx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CM2538SF53 TexasInstruments CM2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\chips\adxl346\; ..\..\..\bsp\chips\max44009\; ..\..\..\bsp\chips\sht21\; ..\..\..\bsp\chips\cc2538rf\; ..\..\..\bsp\chips\at86rf215\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\OpenwsnHeads\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\uecho\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\rrt\; ..\..\..\openapps\uinject\; ..\..\..\bsp\boards\openmote-b\; ..\..\..\bsp\boards\openmote-b\headers\; ..\..\..\bsp\boards\openmote-b\source\; ..\..\..\projects\common\03oos_openwsn; ..\..\..\bsp\chips\si70x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 01bsp_radio_tx.out
  ILINK.IlinkIcfFile: C:\openwsn\iar-plugin\cx2538xf53.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/01bsp_radio_tx/: 01bsp_radio_tx.c
  group bsp/boards
    ../../../bsp/boards/: board.h cryptoengine.h debugpins.h eui64.h i2c.h leds.h radio.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/openmote-b
    ../../../bsp/boards/openmote-b/: adc_sensor.c adc_sensor.h board.c board_info.h cc2538rf.h cryptoengine.c debugpins.c eui64.c i2c.c leds.c radio.c sctimer.c sensors.c spi.c startup_iar.c uart.c
  group bsp/boards/openmote-b/headers
    ../../../bsp/boards/openmote-b/headers/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group bsp/boards/openmote-b/source
    ../../../bsp/boards/openmote-b/source/: adc.c adc.h aes.c aes.h bl_commands.h ccm.c ccm.h cpu.c cpu.h debug.c debug.h ecc_curveinfo.h flash.c flash.h gpio.c gpio.h gptimer.c gptimer.h i2c_lib.c i2c_lib.h interrupt.c interrupt.h ioc.c ioc.h pka.c pka.h rom.h sha256.c sha256.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h systick.c systick.h uarthal.c uarthal.h udma.c udma.h watchdog.c watchdog.h
  group bsp/chips/at86rf215
    ../../../bsp/chips/at86rf215/: at86rf215.c at86rf215.h radio_at86rf215.c radio_at86rf215.h
  group bsp/chips/cc2538rf
    ../../../bsp/chips/cc2538rf/: radio_cc2538rf.c radio_cc2538rf.h
  group bsp/chips/s70x
    ../../../bsp/chips/si70x/: si70x.c si70x.h
  group bsp/chips/sht21
    ../../../bsp/chips/sht21/: sht21.c sht21.h
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154_security.c IEEE802154_security.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: msf.c msf.h neighbors.c neighbors.h processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
