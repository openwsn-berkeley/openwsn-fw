# IAR project 00stdtx_loraspi1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\chips\adxl346\; ..\..\..\bsp\chips\max44009\; ..\..\..\bsp\chips\sht21\; ..\..\..\bsp\chips\si70x\; ..\..\..\bsp\chips\sx1276-mine\; ..\..\..\kernel\; ..\..\..\kernel\openos\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\bsp\boards\openmote-b\; ..\..\..\bsp\boards\openmote-b\headers\; ..\..\..\bsp\boards\openmote-b\source\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\inc\cx2538xf53.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: 00stdtx_loraspi1.c
    ../../../kernel/openos/: scheduler.c
    ../../../kernel/: scheduler.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h crypto_engine.h debugpins.h eui64.h i2c.h leds.h radio.h radiotimer.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/openmote-b
    ../../../bsp/boards/openmote-b/: adc_sensor.c adc_sensor.h board.c board_info.h bsp_timer.c cc2538rf.h cryptoengine.c debugpins.c eui64.c i2c.c leds.c radio.c radiotimer.c sctimer.c sensors.c startup_iar.c uart.c
  group bsp/boards/openmote-b/headers
    ../../../bsp/boards/openmote-b/headers/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group bsp/boards/openmote-b/source
    ../../../bsp/boards/openmote-b/source/: adc.c adc.h aes.c aes.h bl_commands.h ccm.c ccm.h cpu.c cpu.h debug.c debug.h ecc_curveinfo.h flash.c flash.h gpio.c gpio.h gptimer.c gptimer.h i2c_lib.c i2c_lib.h interrupt.c interrupt.h ioc.c ioc.h pka.c pka.h rom.h sha256.c sha256.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h systick.c systick.h uarthal.c uarthal.h udma.c udma.h watchdog.c watchdog.h
  group bsp/chips/adxl346
    ../../../bsp/chips/adxl346/: adxl346.c adxl346.h
  group bsp/chips/max44009
    ../../../bsp/chips/max44009/: max44009.c max44009.h
  group bsp/chips/sht21
    ../../../bsp/chips/sht21/: sht21.c sht21.h
  group bsp/chips/si70x
    ../../../bsp/chips/si70x/: si70x.c si70x.h
  group bsp/chips/sx1276-mine
    ../../../bsp/chips/sx1276-mine/: def_spitxrx.c def_spitxrx.h sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group projects/common/02drv_opentimers
    ../../common/02drv_opentimers/: 02drv_opentimers.c
