# IAR project 00stdtx_loraspi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\common\; ..\..\..\bsp\chips\adxl346\; ..\..\..\bsp\chips\max44009\; ..\..\..\bsp\chips\sht21\; ..\..\..\bsp\chips\si70x\; ..\..\..\kernel\; ..\..\..\kernel\openos\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\bsp\boards\openmote-b\; ..\..\..\bsp\boards\openmote-b\headers\; ..\..\..\bsp\boards\openmote-b\source\; ..\..\..\projects\openmote-b\00stdtx_loraspi\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 00stdtx_loraspi.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\X250\Downloads\cx2538xf53.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp/boards
    ../../../bsp/boards/: board.h spi.h toolchain_defs.h
  group bsp/boards/openmote-b
    ../../../bsp/boards/openmote-b/: board.c board_info.h
  group bsp/boards/openmote-b/headers
    ../../../bsp/boards/openmote-b/headers/: hw_ints.h hw_ioc.h hw_memmap.h hw_ssi.h hw_sys_ctrl.h hw_types.h
  group bsp/boards/openmote-b/source
    ../../../bsp/boards/openmote-b/source/: cpu.c cpu.h gpio.c gpio.h interrupt.c interrupt.h ioc.c ioc.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h
  group projects/openmote-b/00stdtx_loraspi
    ./: 00stdtx_loraspi.c combineRegRadio.h delay.h gpio-board.h gpioLora.c gpioLora.h pinName-board.h pinName-ioe.h radio_sx1276.h spiLora.h sx1276-board.h sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h timer.h utilities.h
