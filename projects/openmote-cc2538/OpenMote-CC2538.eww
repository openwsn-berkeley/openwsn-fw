<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_sctimer\01bsp_sctimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\02drv_opentimers\02drv_opentimers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_macpong\03oos_macpong.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_openwsn\03oos_openwsn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_sniffer\03oos_sniffer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


