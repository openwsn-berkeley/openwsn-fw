<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_uart\01bsp_uart.ewp</path>
  </project>
  <batchBuild/>
</workspace>


