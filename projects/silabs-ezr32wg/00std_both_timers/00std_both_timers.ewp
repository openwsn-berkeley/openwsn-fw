# IAR project 00std_both_timers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EZR32WG330F256R60 SiliconLaboratories EZR32WG330F256R60
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EZR32WG330F256R60
  ICCARM.CCIncludePath2: ..\..\..\bsp\boards; ..\..\..\bsp\boards\silabs-ezr32wg; ..\..\..\inc; ..\..\..\bsp\boards\silabs-ezr32wg\headers; ..\..\..\bsp\boards\silabs-ezr32wg\Include; ..\..\..\bsp\boards\silabs-ezr32wg\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: 00std_both_timers.srec
  ILINK.IlinkOutputFile: 00std_both_timers.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: 00std_both_timers.c
    ../../../bsp/boards/silabs-ezr32wg/GCC/: startup_ezr32wg.s
  group source
    ../../../bsp/boards/silabs-ezr32wg/source/: em_cmu.c em_dma.c em_emu.c em_gpio.c em_int.c em_letimer.c em_rmu.c em_rtc.c em_rtcc.c system_ezr32wg.c write.c
