# IAR project 01bsp_spi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EZR32WG330F256R60 SiliconLaboratories EZR32WG330F256R60
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EZR32WG330F256R60
  ICCARM.CCIncludePath2: ..\..\..\bsp\boards; ..\..\..\bsp\boards\silabs-ezr32wg; ..\..\..\inc; ..\..\..\bsp\boards\silabs-ezr32wg\headers; ..\..\..\bsp\boards\silabs-ezr32wg\Include; ..\..\..\bsp\boards\silabs-ezr32wg\source; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\dmadrv\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\common\inc; ..\..\..\bsp\boards\silabs-ezr32wg\kits\SLWSTK6220A_EZR32WG\examples\ezradio_simple_trx\config; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\ezradiodrv\common\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\ezradiodrv\common\inc\si4x6x; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\ezradiodrv\si4460\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\gpiointerrupt\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\spidrv\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\config; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\nvm\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\rtcdrv\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\sleep\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\tempdrv\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\ustimer\inc; ..\..\..\bsp\boards\silabs-ezr32wg\emdrv\uartdrv\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 01bsp_spi.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../../bsp/boards/silabs-ezr32wg/: 01bsp_spi_ezr32.c
  group bsp/board/silabs-ezr32wg
    ../../../bsp/boards/silabs-ezr32wg/: adc_sensor.c adc_sensor.h board.c board_info.h bsp_timer.c bspconfig.h debugpins.c eui64.c i2c.c i2cspmconfig.h leds.c radio-config-wds-gen.h radio.c spi.c uart.c
  group bsp/board/silabs-ezr32wg/CMSIS
    ../../../bsp/boards/silabs-ezr32wg/GCC/: startup_ezr32wg.S
  group bsp/board/silabs-ezr32wg/drivers
    ../../../bsp/boards/silabs-ezr32wg/emdrv/dmadrv/inc/: dmactrl.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/dmadrv/src/: dmadrv.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/ezradiodrv/common/src/: ezradio_api_lib.c ezradio_comm.c ezradio_hal.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/ezradiodrv/common/src/si4x6x/: ezradio_api_lib_add.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/spidrv/src/: spidrv.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/uartdrv/src/: uartdrv.c
    ../../../bsp/boards/silabs-ezr32wg/emdrv/ustimer/src/: ustimer.c
  group bsp/board/silabs-ezr32wg/source
    ../../../bsp/boards/silabs-ezr32wg/source/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_crc.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c system_ezr32wg.c write.c
  group inc
    ../../../inc/: opendefs.h
