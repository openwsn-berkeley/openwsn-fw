# IAR project 01bsp_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EZR32WG330F256R60 SiliconLaboratories EZR32WG330F256R60
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EZR32WG330F256R60; DEBUG_EFM
  ICCARM.CCIncludePath2: C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\inc; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\GCC; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\headers; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\Include; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\inc; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\GCC; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\headers; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\Include; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\boards\silabs-ezr32wg\source; C:\Users\Usuario\Desktop\ezr32wg330f256r60\openwsn-fw\bsp\chips
  OBJCOPY.OOCOutputFile: 01bsp_uart.bin
  ILINK.IlinkOutputFile: 01bsp_uart.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/01bsp_uart/: 01bsp_uart.c
  group bsp/boards/silabs-ezr32wg
    ../../../bsp/boards/silabs-ezr32wg/: adc_sensor.c board.c board_info.h bsp_timer.c bspconfig.h debugpins.c eui64.c i2c.c leds.c radio.c radiotimer.c uart.c
  group bsp/boards/silabs-ezr32wg/CMSIS
    ../../../../../../../../SiliconLabs/SimplicityStudio/v3/developer/sdks/efm32/v2/Device/SiliconLabs/EZR32WG/Source/IAR/: startup_ezr32wg.s
  group bsp/boards/silabs-ezr32wg/source
    ../../../bsp/boards/silabs-ezr32wg/source/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_crc.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
    ../../../bsp/boards/silabs-ezr32wg/: system_ezr32wg.c
    $EW_DIR$/arm/src/lib/: write.c
  group inc
    ../../../inc/: opendefs.h
