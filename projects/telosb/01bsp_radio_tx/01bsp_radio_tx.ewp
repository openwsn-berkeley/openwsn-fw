# IAR project 01bsp_radio_tx.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\; ..\..\..\bsp\boards\telosb\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\inc\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/01bsp_radio_tx/: 01bsp_radio_tx.c
  group bsp
    ../../../bsp/boards/telosb/: board.c board_info.h bsp_timer.c debugpins.c debugpins.h leds.c radiotimer.c spi.c uart.c
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h leds.h radio.h radiotimer.h uart.h
    ../../../bsp/chips/cc2420/: cc2420.h radio.c
    ../../../bsp/chips/: spi.h
  group inc
    ../../../inc/: opendefs.h
