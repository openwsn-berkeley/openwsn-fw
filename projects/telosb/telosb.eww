<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\00std_button\00std_button.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_chromatic\00std_chromatic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_clocks\00std_clocks.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_eui64\00std_eui64.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_i2c\00std_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_leds_xtal\00std_leds_xtal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_spi\00std_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_uart\00std_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_uart0\00std_uart0.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_debugs</name>
      <member>
        <project>00std_button</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_chromatic</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_clocks</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_eui64</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_i2c</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_leds_xtal</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_spi</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_uart</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>00std_uart0</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


