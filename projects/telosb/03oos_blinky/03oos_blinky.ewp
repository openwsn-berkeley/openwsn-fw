# IAR project 03oos_blinky.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\telosb\; ..\..\..\drivers\; ..\..\..\drivers\common\; ..\..\..\drivers\telosb\; ..\..\..\inc\; ..\..\..\kernel\; ..\..\..\kernel\freertos\; ..\..\..\kernel\freertos\FreeRTOSV8.1.2\FreeRTOS\Source\include\; ..\..\..\kernel\freertos\FreeRTOSV8.1.2\FreeRTOS\Source\portable\IAR\MSP430\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openapps\; ..\..\..\openapps\heli\; ..\..\..\openapps\imu\; ..\..\..\openapps\layerdebug\; ..\..\..\openapps\r6t\; ..\..\..\openapps\rleds\; ..\..\..\openapps\rreg\; ..\..\..\openapps\rwellknown\; ..\..\..\openapps\rt\; ..\..\..\openapps\rrt\; ..\..\..\openapps\rex\; ..\..\..\openapps\rinfo\; ..\..\..\openapps\rheli\; ..\..\..\openapps\rxl1\; ..\..\..\openapps\rsched\; ..\..\..\openapps\rrube\; ..\..\..\openapps\ohlone\; ..\..\..\openapps\tcpecho\; ..\..\..\openapps\tcpinject\; ..\..\..\openapps\tcpprint\; ..\..\..\openapps\udpecho\; ..\..\..\openapps\udpinject\; ..\..\..\openapps\udpprint\; ..\..\..\openapps\udprand\; ..\..\..\openapps\udpstorm\; ..\..\..\openapps\udplatency\; ..\..\..\openstack\cross-layers\; ..\..\..\drivers\common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..\..\..\kernel\freertos\
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_blinky/: 03oos_blinky.c
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c spi.c uart.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.h radio.c
  group drivers
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/: scheduler.h
  group kernel/freertos
    ../../../kernel/freertos/: FreeRTOSConfig.h scheduler.c
  group kernel/freertos/FreeRTOSV8.1.2
    ../../../kernel/freertos/FreeRTOSV8.1.2/FreeRTOS/Source/: list.c queue.c tasks.c
  group kernel/freertos/FreeRTOSV8.1.2/include
    ../../../kernel/freertos/FreeRTOSV8.1.2/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group kernel/freertos/FreeRTOSV8.1.2/portable
    ../../../kernel/freertos/FreeRTOSV8.1.2/FreeRTOS/Source/portable/IAR/MSP430/: port.c portasm.h portext.s43 portmacro.h
  group kernel/freertos/FreeRTOSV8.1.2/portable/MemMang
    ../../../kernel/freertos/FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group kernel/openos
    ../../../kernel/openos/: scheduler.c
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h processIE.c processIE.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
