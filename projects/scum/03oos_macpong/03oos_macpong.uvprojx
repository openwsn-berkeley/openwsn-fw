# Keil uVision project 03oos_macpong.uvprojx, settings and files
target Target SCuM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 03oos_macpong
  AfterMake: fromelf --bin .\Objects\03oos_macpong.axf -o .\Objects\03oos_macpong.bin
  AfterMake: fromelf -cvf .\Objects\03oos_macpong.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum;..\..\..\drivers\common;..\..\..\inc;..\..\..\openstack\02a-MAClow;..\..\..\openstack\02b-MAChigh;..\..\..\openstack\03a-IPHC;..\..\..\openstack\03b-IPv6;..\..\..\openstack\04-TRAN;..\..\..\openstack\cross-layers;..\..\..\kernel;..\..\..\openapps;..\..\..\openstack;..\..\..\bsp\boards\common
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../../common/03oos_macpong/: 03oos_macpong.c
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h bsp_timer.h
  group scum
    ../../../bsp/boards/scum/: cm0dsasm.s leds.c memory_map.h board_info.h board.c uart.c bsp_timer.c radiotimer.c debugpins.c radio.c eui64.c
    ../../../bsp/boards/common/: dummy_crypto_engine.c
  group drivers
    ../../../drivers/common/: opentimers.c openhdlc.c openserial.c
  group inc
    ../../../inc/: opendefs.h
  group stack_initial
    ../../../openstack/: openstack.c openstack.h
  group 02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c IEEE802154.c IEEE802154_dummy_security.c IEEE802154_security.c IEEE802154E.c topology.c
  group 02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c processIE.c schedule.c sf0.c sixtop.c
  group cross-layers
    ../../../openstack/cross-layers/: idmanager.c openqueue.c openrandom.c packetfunctions.c
  group kernel
    ../../../kernel/openos/: scheduler.c
