# Keil uVision project 01bsp_leds.uvprojx, settings and files
target Target SCuM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 01bsp_leds +hex
  AfterMake: fromelf --bin .\Objects\01bsp_leds.axf -o .\Objects\01bsp_leds.bin
  AfterMake: fromelf -cvf .\Objects\01bsp_leds.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../../common/01bsp_leds/: 01bsp_leds.c
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h uart.h sctimer.h
  group scum
    ../../../bsp/boards/scum/: leds.c memory_map.h board_info.h board.c debugpins.c eui64.c radio.c sctimer.c uart.c scm3_hardware_interface.c scm3_hardware_interface.h bucket_o_functions.c bucket_o_functions.h retarget.c
  group startUp
    ../../../bsp/boards/scum/: cm0dsasm.s
