# Keil uVision project 01bsp_sctimer_gpio.uvprojx, settings and files
target Target SCuM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 01bsp_sctimer_gpio +hex
  AfterMake: fromelf --bin .\Objects\01bsp_sctimer_gpio.axf -o .\Objects\01bsp_sctimer_gpio.bin
  AfterMake: fromelf -cvf .\Objects\01bsp_sctimer_gpio.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./: 01bsp_sctimer_gpio.c
  group startUp
    ../../../bsp/boards/scum/: cm0dsasm.s
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h sctimer.h uart.h
  group scum
    ../../../bsp/boards/scum/: board.c debugpins.c eui64.c leds.c radio.c sctimer.c uart.c board_info.h memory_map.h scm3_hardware_interface.c scm3_hardware_interface.h bucket_o_functions.c bucket_o_functions.h retarget.c
