# Keil uVision project 01bsp_multipletimer_radio.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 01bsp_multipletimer_radio +hex
  AfterMake: fromelf --bin .\Objects\01bsp_multipletimer_radio.axf -o .\Objects\01bsp_multipletimer_radio.bin
  AfterMake: fromelf -cvf .\Objects\01bsp_multipletimer_radio.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./: 01bsp_multipletimer_radio.c
  group startUp
    ../../../bsp/boards/scum/: cm0dsasm.s
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h sctimer.h uart.h
  group scum
    ../../../bsp/boards/scum/: board_info.h memory_map.h board.c debugpins.c eui64.c leds.c radio.c sctimer.c uart.c scm3_hardware_interface.c scm3_hardware_interface.h
