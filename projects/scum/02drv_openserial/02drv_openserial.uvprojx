# Keil uVision project 02drv_openserial.uvprojx, settings and files
target Target SCuM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 02drv_openserial
  AfterMake: fromelf --bin .\Objects\02drv_openserial.axf -o .\Objects\02drv_openserial.bin
  AfterMake: fromelf -cvf .\Objects\02drv_openserial.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum;..\..\..\drivers\common;..\..\..\inc;..\..\..\openstack\02a-MAClow;..\..\..\openstack\02b-MAChigh;..\..\..\openstack\03a-IPHC;..\..\..\openstack\03b-IPv6;..\..\..\openstack\04-TRAN;..\..\..\openstack\cross-layers
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ../../common/02drv_openserial/: 02drv_openserial.c
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h bsp_timer.h
  group scum
    ../../../bsp/boards/scum/: cm0dsasm.s leds.c memory_map.h board_info.h board.c uart.c bsp_timer.c radiotimer.c debugpins.c radio.c
  group drivers
    ../../../drivers/common/: openserial.c openhdlc.c opentimers.c openhdlc.h openserial.h opentimers.h
  group inc
    ../../../inc/: opendefs.h
