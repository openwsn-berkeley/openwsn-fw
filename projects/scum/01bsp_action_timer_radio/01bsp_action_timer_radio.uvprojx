# Keil uVision project 01bsp_action_timer_radio.uvprojx, settings and files
target Target SCuM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: 01bsp_action_timer_radio +hex
  AfterMake: fromelf --bin .\Objects\01bsp_action_timer_radio.axf -o .\Objects\01bsp_action_timer_radio.bin
  AfterMake: fromelf -cvf .\Objects\01bsp_action_timer_radio.axf -o .\Objects\disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\bsp\boards;..\..\..\bsp\boards\scum
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group application
    ./: 01bsp_action_timer_radio.c
  group startUp
    ../../../bsp/boards/scum/: cm0dsasm.s
  group boards
    ../../../bsp/boards/: board.h debugpins.h eui64.h leds.h radio.h uart.h sctimer.h
  group scum
    ../../../bsp/boards/scum/: leds.c memory_map.h board_info.h board.c uart.c debugpins.c radio.c eui64.c sctimer.c scm3_hardware_interface.c scm3_hardware_interface.h
