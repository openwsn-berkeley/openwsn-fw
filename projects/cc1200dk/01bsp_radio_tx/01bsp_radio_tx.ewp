# IAR project 01bsp_radio_tx.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\; ..\..\..\bsp\boards\cc1200dk\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc1200\; ..\..\..\bsp\boards\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group application
    ../../common/01bsp_radio_tx/: 01bsp_radio_tx.c
  group bsp
    ../../../bsp/boards/cc1200dk/: board.c board_info.h bsp.c bsp_timer.c debugpins.c leds.c radiotimer.c spi.c uart.c
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h leds.h radio.h radiotimer.h spi.h uart.h
    ../../../bsp/boards/MSP430F5438A/: bsp.h
    ../../../bsp/chips/cc1200/: cc1200.c cc1200.h radio.c
