# IAR project 01bsp_closetimers.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group application
    ../../common/01bsp_closetimers/: 01bsp_closetimers.c
  group bsp
    ../../../bsp/boards/MSP430F5438A/: board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c spi.c uart.c
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h leds.h radio.h radiotimer.h spi.h uart.h
