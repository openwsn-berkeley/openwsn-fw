# IAR project 01bsp_uart.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\bsp\boards\; ..\..\..\bsp\boards\MSP430F5438A\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\boards\bsp\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group application
    ../../common/01bsp_uart/: 01bsp_uart.c
  group bsp
    ../../../bsp/boards/MSP430F5438A/: board.c board_info.h bsp_timer.c debugpins.c leds.c radiotimer.c uart.c
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h leds.h radiotimer.h uart.h
