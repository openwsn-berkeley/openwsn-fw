# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CM2538SF53 TexasInstruments CM2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\OpenMote-CC2538\; ..\..\..\bsp\boards\OpenMote-CC2538\inc\; ..\..\..\bsp\boards\OpenMote-CC2538\source\; ..\..\..\drivers\; ..\..\..\drivers\common\; ..\..\..\kernel\openos\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openapps\; ..\..\..\openapps\heli\; ..\..\..\openapps\imu\; ..\..\..\openapps\layerdebug\; ..\..\..\openapps\r6t\; ..\..\..\openapps\rleds\; ..\..\..\openapps\rreg\; ..\..\..\openapps\rwellknown\; ..\..\..\openapps\rt\; ..\..\..\openapps\rrt\; ..\..\..\openapps\rex\; ..\..\..\openapps\rinfo\; ..\..\..\openapps\rheli\; ..\..\..\openapps\rxl1\; ..\..\..\openapps\rsched\; ..\..\..\openapps\rrube\; ..\..\..\openapps\ohlone\; ..\..\..\openapps\tcpecho\; ..\..\..\openapps\tcpinject\; ..\..\..\openapps\tcpprint\; ..\..\..\openapps\udpecho\; ..\..\..\openapps\udpinject\; ..\..\..\openapps\udpprint\; ..\..\..\openapps\udprand\; ..\..\..\openapps\udpstorm\; ..\..\..\openapps\udplatency\; ..\..\..\openstack\cross-layers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: 03oos_openwsn.d43
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/OpenMote-CC2538/: board.c board_info.h bsp_timer.c cc2538rf.h debugpins.c eui64.c leds.c radio.c radiotimer.c startup_gcc.c uart.c
  group bsp/boards/inc
    ../../../bsp/boards/OpenMote-CC2538/inc/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group bsp/boards/source
    ../../../bsp/boards/OpenMote-CC2538/source/: adc.c adc.h aes.c aes.h bl_commands.h ccm.c ccm.h cpu.c cpu.h debug.c debug.h ecc_curveinfo.h flash.c flash.h gpio.c gpio.h gptimer.c gptimer.h i2c.c i2c.h interrupt.c interrupt.h ioc.c ioc.h pka.c pka.h rom.h sha256.c sha256.h sleepmode.c sleepmode.h ssi.c ssi.h sys_ctrl.c sys_ctrl.h systick.c systick.h uarthal.c uarthal.h udma.c udma.h watchdog.c watchdog.h
  group drivers
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../../openstack/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openwsn/02b-MAChigh
    ../../../openstack/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h sixtop.c sixtop.h processIE.c processIE.h schedule.c schedule.h
  group openwsn/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openwsn/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openwsn/04-TRAN
    ../../../openstack/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h rsvp.c rsvp.h
  group openwsn/07-App/layerdebug
    ../../../openapps/layerdebug/: layerdebug.c layerdebug.h
  group openwsn/07-App/ohlone
    ../../../openapps/ohlone/: ohlone.c ohlone.h ohlone_webpages.c ohlone_webpages.h
  group openwsn/07-App/r6t
    ../../../openapps/r6t/: r6t.c r6t.h
  group openwsn/07-App/rex
    ../../../openapps/rex/: rex.c rex.h
  group openwsn/07-App/rinfo
    ../../../openapps/rinfo/: rinfo.c rinfo.h
  group openwsn/07-App/rleds
    ../../../openapps/rleds/: rleds.c rleds.h
  group openwsn/07-App/rreg
    ../../../openapps/rreg/: rreg.c rreg.h
  group openwsn/07-App/rrt
    ../../../openapps/rrt/: rrt.c rrt.h
  group openwsn/07-App/rwellknown
    ../../../openapps/rwellknown/: rwellknown.c rwellknown.h
  group openwsn/07-App/tcpecho
    ../../../openapps/tcpecho/: tcpecho.c tcpecho.h
  group openwsn/07-App/tcpinject
    ../../../openapps/tcpinject/: tcpinject.c tcpinject.h
  group openwsn/07-App/tcpprint
    ../../../openapps/tcpprint/: tcpprint.c tcpprint.h
  group openwsn/07-App/udpecho
    ../../../openapps/udpecho/: udpecho.c udpecho.h
  group openwsn/07-App/udpinject
    ../../../openapps/udpinject/: udpinject.c udpinject.h
  group openwsn/07-App/udplatency
    ../../../openapps/udplatency/: udplatency.c udplatency.h
  group openwsn/07-App/udpprint
    ../../../openapps/udpprint/: udpprint.c udpprint.h
  group openwsn/07-App/udprand
    ../../../openapps/udprand/: udprand.c udprand.h
  group openwsn/07-App/udpstorm
    ../../../openapps/udpstorm/: udpstorm.c udpstorm.h
  group openwsn/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
