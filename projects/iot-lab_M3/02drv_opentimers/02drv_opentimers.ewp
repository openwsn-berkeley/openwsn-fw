# IAR project 02drv_opentimers.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\bsp\boards\iot-lab_M3\; ..\..\..\bsp\boards\iot-lab_M3\configure\; ..\..\..\bsp\boards\iot-lab_M3\library\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\bsp\boards\iot-lab_M3\library\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\projects\common\03drv_opentimer\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 02drv_opentimers.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/02drv_opentimers/: 02drv_opentimers.c
  group bsp/boards/iot-lab_M3
    ../../../bsp/boards/iot-lab_M3/: board.c bsp_timer.c debugpins.c eui64.c exti.c gpio.c leds.c nvic.c radiotimer.c rcc.c spi.c uart.c
  group bsp/boards/iot-lab_M3/library
    ../../../bsp/boards/iot-lab_M3/library/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: radio.c
  group drivers/common
    ../../../drivers/common/: opentimers.c opentimers.h
