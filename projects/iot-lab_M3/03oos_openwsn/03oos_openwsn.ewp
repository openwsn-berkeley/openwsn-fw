# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; HSE_VALUE=((uint32_t)16000000)
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\inc\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\03a-IPHC\; ..\..\..\openstack\03b-IPv6\; ..\..\..\openstack\04-TRAN\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\c6t\; ..\..\..\openapps\cexample\; ..\..\..\openapps\cinfo\; ..\..\..\openapps\cleds\; ..\..\..\openapps\cjoin\; ..\..\..\openapps\cstorm\; ..\..\..\openapps\cwellknown\; ..\..\..\openapps\uecho\; ..\..\..\openapps\uexpiration\; ..\..\..\openapps\uexpiration_monitor\; ..\..\..\openapps\rrt\; ..\..\..\openapps\uinject\; ..\..\..\openapps\userialbridge\; ..\..\..\openapps\opencoap\; ..\..\..\bsp\boards\iot-lab_M3\; ..\..\..\bsp\boards\iot-lab_M3\configure\; ..\..\..\bsp\boards\iot-lab_M3\library\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\bsp\boards\iot-lab_M3\library\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\projects\common\03oos_openwsn\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 03oos_openwsn.srec
  ILINK.IlinkOutputFile: 03oos_openwsn.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c
  group bsp/boards/common
    ../../../bsp/boards/common/: openaes.c openaes.h openccms.c openccms.h
  group bsp/boards/iot-lab_M3
    ../../../bsp/boards/iot-lab_M3/: board.c cryptoengine.c debugpins.c eui64.c exti.c gpio.c leds.c nvic.c rcc.c sctimer.c spi.c uart.c
  group bsp/boards/iot-lab_M3/configure
    ../../../bsp/boards/iot-lab_M3/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/iot-lab_M3/library
    ../../../bsp/boards/iot-lab_M3/library/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../../../bsp/boards/iot-lab_M3/library/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../../bsp/boards/iot-lab_M3/library/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c opensensors.c openserial.c opentimers.c
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/openos/: scheduler.c
  group openapps
    ../../../openapps/: openapps.c
  group openapps/c6t
    ../../../openapps/c6t/: c6t.c
  group openapps/cexample
    ../../../openapps/cexample/: cexample.c
  group openapps/cinfo
    ../../../openapps/cinfo/: cinfo.c
  group openapps/cjoin
    ../../../openapps/cjoin/: cjoin.c cjoin.h cojp_cbor.c cojp_cbor.h
  group openapps/cleds
    ../../../openapps/cleds/: cleds.c
  group openapps/csensors
    ../../../openapps/csensors/: csensors.c
  group openapps/cstorm
    ../../../openapps/cstorm/: cstorm.c
  group openapps/cwellknown
    ../../../openapps/cwellknown/: cwellknown.c
  group openapps/opencoap
    ../../../openapps/opencoap/: cborencoder.c cborencoder.h hkdf.c hmac.c opencoap.c opencoap.h openoscoap.c openoscoap.h sha-private.h sha.h sha224-256.c usha.c
  group openapps/rtt
    ../../../openapps/rrt/: rrt.c
  group openapps/uecho
    ../../../openapps/uecho/: uecho.c
  group openapps/uinject
    ../../../openapps/uinject/: uinject.c
  group openapps/userialbridge
    ../../../openapps/userialbridge/: userialbridge.c
  group openstack
    ../../../openstack/: openstack.c
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c IEEE802154.c IEEE802154_security.c IEEE802154E.c topology.c
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: msf.c neighbors.c schedule.c sixtop.c
  group openstack/03a-IPHC
    ../../../openstack/03a-IPHC/: iphc.c openbridge.c
  group openstack/03b-IPv6
    ../../../openstack/03b-IPv6/: forwarding.c icmpv6.c icmpv6echo.c icmpv6rpl.c
  group openstack/04-TRAN
    ../../../openstack/04-TRAN/: openudp.c
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c openqueue.c openrandom.c packetfunctions.c
