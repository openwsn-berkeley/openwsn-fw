<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\program_eui64.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_leds_xtal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_button.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_serial.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_i2c_connnected_slaves.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_large_range_accel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_sensitive_accel_temperature.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_gyro.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_magnetometer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_imu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_radio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_hybrid_arq.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\test_imu_radio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\iar_projects\telosb\openwsn.ewp</path>
  </project>
  <batchBuild/>
</workspace>


