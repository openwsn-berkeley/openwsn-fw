# IAR project 00std_uart01_dante.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\stm32\configure\; ..\..\..\bsp\boards\stm32\library\inc\; ..\..\..\bsp\boards\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 00std_uart01_dante.hex
  ILINK.IlinkOutputFile: 00std_uart01_dante.out
  ILINK.IlinkIcfFile: F:\TestForSTM32\bsp\boards\stm32\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ../../../bsp/boards/stm32/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group FWlib
    ../../../bsp/boards/stm32/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c
  group USER
    ../../../bsp/boards/stm32/: leds.c uart.c
    ../../../bsp/boards/: leds.h uart.h
    ../../../bsp/boards/stm32/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../common/uart01_test/: uart01_test.c
