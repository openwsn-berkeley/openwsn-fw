# IAR project 02drv_opentimer_dante.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\bsp\boards\stm32\configure\; ..\..\..\bsp\boards\stm32\library\inc\; ..\..\..\bsp\boards\; ..\..\..\openwsn\; ..\..\..\drivers\common\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 02drv_opentimer_dante.hex
  ILINK.IlinkOutputFile: 02drv_opentimer_dante.out
  ILINK.IlinkIcfFile: F:\TestForSTM32\bsp\boards\stm32\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/opentimer_test/: 02drv_opentimer.c
  group bsp/boards
    ../../../bsp/boards/: board.h board_info.h bsp_timer.h exi.h leds.h radio.h radiotimer.h spi.h Systick.h uart.h
  group bsp/boards/chips
    ../../../bsp/chip/: spi.h
  group bsp/boards/chips/at86f231
    ../../../bsp/chip/at86rf231/: at86rf231.h radio.c
  group bsp/boards/stm32
    ../../../bsp/boards/stm32/: board.c bsp_timer.c exi.c leds.c radiotimer.c spi.c Systick.c uart.c
  group bsp/boards/stm32/config
    ../../../bsp/boards/stm32/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/stm32/ewarm
    ../../../bsp/boards/stm32/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/stm32/lib
    ../../../bsp/boards/stm32/library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group bsp/drivers
    ../../../drivers/common/: opentimers.c opentimers.h
