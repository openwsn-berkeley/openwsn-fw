# IAR project 00300s_openwsn_dante.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\stm32\configure\; ..\..\..\bsp\boards\stm32\library\inc\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\openwsn\OpenwsnHeads\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 00300s_openwsn_dante.hex
  ILINK.IlinkOutputFile: 00300s_openwsn_dante.out
  ILINK.IlinkIcfFile: F:\TestForSTM32\bsp\boards\stm32\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/openwsn_test/: openwsn_test.c openwsn_test.h
  group bsp/boards
    ../../../bsp/boards/: board.h board_info.h bsp_timer.h debugpins.h exi.h gpio.h leds.h radio.h rtc_timer.h spi.h Systick.h uart.h
  group bsp/boards/stm32
    ../../../bsp/boards/stm32/: bsp_timer.c debugpins.c exi.c gpio.c leds.c rtc_timer.c spi.c Systick.c uart.c
  group bsp/boards/stm32/config
    ../../../bsp/boards/stm32/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/stm32/ewarm
    ../../../bsp/boards/stm32/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/stm32/lib
    ../../../bsp/boards/stm32/library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group bsp/chips
    ../../../bsp/chip/: spi.h
  group bsp/chips/at86f231
    ../../../bsp/chip/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openserial.c openserial.h opentimers.c opentimers.h
  group kernel
    ../../../kernel/: scheduler.c scheduler.h
  group openwsn
    ../../../openwsn/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openwsn/02a-MAClow/: IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h
  group openwsn/02b-MAChigh
    ../../../openwsn/02b-MAChigh/: linkcost.c linkcost.h neighbors.c neighbors.h res.c res.h schedule.c schedule.h
  group openwsn/03a-IPHC
    ../../../openwsn/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openwsn/03b-IPv6
    ../../../openwsn/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6router.c icmpv6router.h icmpv6rpl.c icmpv6rpl.h
  group openwsn/04-TRAN
    ../../../openwsn/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group openwsn/cross-layers
    ../../../openwsn/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
