<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_i2c.ewp</path>
  </project>
  <batchBuild/>
</workspace>


