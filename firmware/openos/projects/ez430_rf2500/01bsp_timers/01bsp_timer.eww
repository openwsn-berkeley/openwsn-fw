<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\gina\01bsp_timer\01bsp_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\telosb\01bsp_timer\01bsp_timer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


