# IAR project 03oos_macpong.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 200
  General.GHeapSize2: 200
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc1101\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\wsn430v13b\; ..\..\..\drivers\; ..\..\..\drivers\common\; ..\..\..\drivers\wsn430v13b\; ..\..\..\openwsn\; ..\..\..\kernel\openos\; ..\..\..\openwsn\; ..\..\..\openwsn\02a-MAClow\; ..\..\..\openwsn\02b-MAChigh\; ..\..\..\openwsn\03a-IPHC\; ..\..\..\openwsn\03b-IPv6\; ..\..\..\openwsn\04-TRAN\; ..\..\..\openwsn\07-App\; ..\..\..\openwsn\07-App\heli\; ..\..\..\openwsn\07-App\imu\; ..\..\..\openwsn\07-App\layerdebug\; ..\..\..\openwsn\07-App\r6t\; ..\..\..\openwsn\07-App\rleds\; ..\..\..\openwsn\07-App\rreg\; ..\..\..\openwsn\07-App\rwellknown\; ..\..\..\openwsn\07-App\rt\; ..\..\..\openwsn\07-App\rrt\; ..\..\..\openwsn\07-App\rex\; ..\..\..\openwsn\07-App\rinfo\; ..\..\..\openwsn\07-App\rheli\; ..\..\..\openwsn\07-App\rxl1\; ..\..\..\openwsn\07-App\rsched\; ..\..\..\openwsn\07-App\rrube\; ..\..\..\openwsn\07-App\ohlone\; ..\..\..\openwsn\07-App\tcpecho\; ..\..\..\openwsn\07-App\tcpinject\; ..\..\..\openwsn\07-App\tcpprint\; ..\..\..\openwsn\07-App\udpecho\; ..\..\..\openwsn\07-App\udpinject\; ..\..\..\openwsn\07-App\udpprint\; ..\..\..\openwsn\07-App\udprand\; ..\..\..\openwsn\07-App\udpstorm\; ..\..\..\openwsn\07-App\udplatency\; ..\..\..\openwsn\cross-layers\; ..\..\..\drivers\common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_macpong/: 03oos_macpong.c 03oos_macpong.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/wsn430v13b
    ../../../bsp/boards/wsn430v13b/: board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c spi.c uart.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/cc1101
    ../../../bsp/chips/cc1101/: cc1101.h radio.c
  group drivers
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../../openwsn/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openwsn/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openwsn/02b-MAChigh
    ../../../openwsn/02b-MAChigh/: neighbors.c neighbors.h sixtop.c sixtop.h processIE.c processIE.h schedule.c schedule.h
  group openwsn/cross-layers
    ../../../openwsn/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
