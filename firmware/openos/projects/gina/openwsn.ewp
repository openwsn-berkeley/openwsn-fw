# IAR project openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 500
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: OPENWSN_STACK
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\drivers\; ..\..\drivers\gina\; ..\..\bsp\; ..\..\bsp\gina\; ..\..\openwsn\; ..\..\kernel\openos\; ..\..\openwsn\02a-MAClow\; ..\..\openwsn\02b-MAChigh\; ..\..\openwsn\03a-IPHC\; ..\..\openwsn\03b-IPv6\; ..\..\openwsn\04-TRAN\; ..\..\openwsn\07-App\; ..\..\openwsn\07-App\heli\; ..\..\openwsn\07-App\imu\; ..\..\openwsn\07-App\rleds\; ..\..\openwsn\07-App\rreg\; ..\..\openwsn\07-App\rwellknown\; ..\..\openwsn\07-App\rt\; ..\..\openwsn\07-App\rinfo\; ..\..\openwsn\07-App\rheli\; ..\..\openwsn\07-App\rxl1\; ..\..\openwsn\07-App\rrube\; ..\..\openwsn\07-App\ohlone\; ..\..\openwsn\07-App\tcpecho\; ..\..\openwsn\07-App\tcpinject\; ..\..\openwsn\07-App\tcpprint\; ..\..\openwsn\07-App\udpecho\; ..\..\openwsn\07-App\udpinject\; ..\..\openwsn\07-App\udpprint\; ..\..\openwsn\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: openwsn_proj.c
  group bsp
    ../../bsp/gina/: board.c board_info.h leds.c
    ../../bsp/: board.h leds.h
  group drivers
    ../../drivers/gina/: gyro.c heli.c i2c.c ieee154etimer.c large_range_accel.c magnetometer.c openserial.c opentimers.c radio.c sensitive_accel_temperature.c spi.c
  group kernel
    ../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../openwsn/: openwsn.c
  group openwsn/02a-MAClow
    ../../openwsn/02a-MAClow/: IEEE802154.c IEEE802154E.c
  group openwsn/02b-MAChigh
    ../../openwsn/02b-MAChigh/: neighbors.c res.c schedule.c
  group openwsn/03a-IPHC
    ../../openwsn/03a-IPHC/: iphc.c openbridge.c
  group openwsn/03b-IPv6
    ../../openwsn/03b-IPv6/: forwarding.c icmpv6.c icmpv6echo.c icmpv6router.c icmpv6rpl.c
  group openwsn/04-TRAN
    ../../openwsn/04-TRAN/: opencoap.c opentcp.c openudp.c
  group openwsn/07-App/heli
    ../../openwsn/07-App/heli/: heli.c
  group openwsn/07-App/imu
    ../../openwsn/07-App/imu/: imu.c
  group openwsn/07-App/ohlone
    ../../openwsn/07-App/ohlone/: ohlone.c ohlone_webpages.c
  group openwsn/07-App/rheli
    ../../openwsn/07-App/rheli/: rheli.c
  group openwsn/07-App/rinfo
    ../../openwsn/07-App/rinfo/: rinfo.c
  group openwsn/07-App/rleds
    ../../openwsn/07-App/rleds/: rleds.c
  group openwsn/07-App/rreg
    ../../openwsn/07-App/rreg/: rreg.c
  group openwsn/07-App/rrube
    ../../openwsn/07-App/rrube/: rrube.c
  group openwsn/07-App/rt
    ../../openwsn/07-App/rt/: rt.c
  group openwsn/07-App/rwellknown
    ../../openwsn/07-App/rwellknown/: rwellknown.c
  group openwsn/07-App/tcpecho
    ../../openwsn/07-App/tcpecho/: tcpecho.c
  group openwsn/07-App/tcpinject
    ../../openwsn/07-App/tcpinject/: tcpinject.c
  group openwsn/07-App/tcpprint
    ../../openwsn/07-App/tcpprint/: tcpprint.c
  group openwsn/07-App/udpecho
    ../../openwsn/07-App/udpecho/: udpecho.c
  group openwsn/07-App/udpinject
    ../../openwsn/07-App/udpinject/: udpinject.c
  group openwsn/07-App/udpprint
    ../../openwsn/07-App/udpprint/: udpprint.c
  group openwsn/07-App/xl1
    ../../openwsn/07-App/rxl1/: rxl1.c
  group openwsn/cross-layers
    ../../openwsn/cross-layers/: idmanager.c openqueue.c openrandom.c packetfunctions.c
