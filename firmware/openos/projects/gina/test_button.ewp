# IAR project test_button.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISR_BUTTON; TEST_BUTTON
  ICC430.newCCIncludePaths: ..\..\drivers\; ..\..\drivers\gina\; ..\..\openwsn\; ..\..\openwsn\02a-MAClow\; ..\..\openwsn\02b-MAChigh\; ..\..\openwsn\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: test_button.c
  group drivers
    ../../drivers/gina/: board.c button.c leds.c scheduler.c
