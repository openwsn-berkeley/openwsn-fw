<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\00std_eui64\00std_eui64.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_leds_xtal\00std_leds_xtal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_timers\00std_timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\00std_uart\00std_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_leds\01bsp_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_uart\01bsp_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_spi\01bsp_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_timer\01bsp_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_radio\01bsp_radio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\02drv_opentimers\02drv_opentimers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\03oos_openwsn\03oos_openwsn.ewp</path>
  </project>
  <batchBuild/>
</workspace>


