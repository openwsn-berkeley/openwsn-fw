# IAR project test_hybrid_arq.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 500
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISR_RADIO; ISR_BUTTON; HYBRID_ARQ
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\drivers\gina; ..\..\openwsn; ..\..\openwsn\02a-MAC; ..\..\openwsn\02b-RES; ..\..\openwsn\03a-IPHC; ..\..\openwsn\03b-IPv6; ..\..\openwsn\04-TRAN; ..\..\openwsn\07-App; ..\..\openwsn\cross-layers
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: test_hybrid_arq.c
  group drivers
    ../../drivers/gina/: button.c board.c leds.c radio.c scheduler.c spi.c
  group openwsn
    ../../openwsn/: openwsn.c
  group openwsn/02a-MAC
    ../../openwsn/02a-MAC/: IEEE802154.h
  group openwsn/cross-layers
    ../../openwsn/cross-layers/: idmanager.c openqueue.c openserial.c packetfunctions.c
