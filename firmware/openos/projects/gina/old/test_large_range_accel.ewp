# IAR project test_large_range_accel.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISR_ADC
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\drivers\; ..\..\drivers\gina\; ..\..\openwsn\; ..\..\openwsn\02a-MAClow\; ..\..\openwsn\02b-MAChigh\; ..\..\openwsn\03a-IPHC\; ..\..\openwsn\03b-IPv6\; ..\..\openwsn\04-TRAN\; ..\..\openwsn\07-App\; ..\..\openwsn\07-App\heli\; ..\..\openwsn\07-App\imu\; ..\..\openwsn\07-App\rleds\; ..\..\openwsn\07-App\rreg\; ..\..\openwsn\07-App\rwellknown\; ..\..\openwsn\07-App\rt\; ..\..\openwsn\07-App\rinfo\; ..\..\openwsn\07-App\rheli\; ..\..\openwsn\07-App\rxl1\; ..\..\openwsn\07-App\rrube\; ..\..\openwsn\07-App\ohlone\; ..\..\openwsn\07-App\tcpecho\; ..\..\openwsn\07-App\tcpinject\; ..\..\openwsn\07-App\tcpprint\; ..\..\openwsn\07-App\udpecho\; ..\..\openwsn\07-App\udpinject\; ..\..\openwsn\07-App\udpprint\; ..\..\openwsn\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: test_large_range_accel.c
  group drivers
    ../../drivers/gina/: i2c.c ieee154etimer.c ieee154etimer.h large_range_accel.c leds.c openserial.c opentimers.c scheduler.c
    ../../openwsn/: openwsn.h
