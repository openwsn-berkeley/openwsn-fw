# IAR project openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 500
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISR_RADIO; ISR_TIMERS; ISR_SERIAL; ISR_I2C; ISR_ADC; OPENWSN_STACK
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\drivers\telosb; ..\..\openwsn; ..\..\openwsn\02a-MAClow; ..\..\openwsn\02b-MAChigh; ..\..\openwsn\03a-IPHC; ..\..\openwsn\03b-IPv6; ..\..\openwsn\04-TRAN; ..\..\openwsn\07-App; ..\..\openwsn\cross-layers
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: openwsn_proj.c
  group drivers
    ../../drivers/telosb/: gyro.c i2c.c ieee154etimer.c large_range_accel.c leds.c magnetometer.c radio.c scheduler.c sensitive_accel_temperature.c spi.c telosb.c timers.c
  group openwsn
    ../../openwsn/: openwsn.c
  group openwsn/02a-MAClow
    ../../openwsn/02a-MAClow/: IEEE802154.c IEEE802154E.c
  group openwsn/02b-MAChigh
    ../../openwsn/02b-MAChigh/: neighbors.c res.c schedule.c
  group openwsn/03a-IPHC
    ../../openwsn/03a-IPHC/: iphc.c openbridge.c
  group openwsn/03b-IPv6
    ../../openwsn/03b-IPv6/: forwarding.c icmpv6.c icmpv6echo.c icmpv6router.c icmpv6rpl.c
  group openwsn/04-TRAN
    ../../openwsn/04-TRAN/: tcp.c udp.c
  group openwsn/07-App
    ../../openwsn/07-App/: apptcpecho.c apptcpinject.c apptcpohlone.c apptcpprint.c appudpchannel.c appudpecho.c appudpinject.c appudpleds.c appudpprint.c appudpsensor.c appudptelosb.c appudptimer.c ohlone_webpages.c
  group openwsn/cross-layers
    ../../openwsn/cross-layers/: idmanager.c openqueue.c openserial.c packetfunctions.c random.c
