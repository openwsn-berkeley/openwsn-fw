<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$\00std_low_power_mode\00std_low_power_mode.ewp</path>
    </project>
    
    <project>
        <path>$WS_DIR$\01bsp_flash\01bsp_flash.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_leds\01bsp_leds.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio\01bsp_radio.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio_rx\01bsp_radio_rx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radio_tx\01bsp_radio_tx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_radiotimer\01bsp_radiotimer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_spi\01bsp_spi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_timer\01bsp_timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\01bsp_uart\01bsp_uart.ewp</path>
    </project>
    
    <project>
        <path>$WS_DIR$\02drv_opentimers\02drv_opentimers.ewp</path>
    </project>
    
    <project>
        <path>$WS_DIR$\03oos_macpong\03oos_macpong.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\03oos_openwsn\03oos_openwsn.ewp</path>
    </project>
    <batchBuild/>
</workspace>


