# IAR project 03oos_macpong.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\agilefox\configure\; ..\..\..\bsp\boards\agilefox\library\inc\; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\agilefox\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\openos\; ..\..\..\drivers\common\; ..\..\..\openwsn\; ..\..\..\openwsn\OpenwsnHeads\; ..\..\..\openwsn\02a-MAClow\; ..\..\..\openwsn\02b-MAChigh\; ..\..\..\openwsn\03a-IPHC\; ..\..\..\openwsn\03b-IPv6\; ..\..\..\openwsn\04-TRAN\; ..\..\..\openwsn\07-App\; ..\..\..\openwsn\07-App\bbk\; ..\..\..\openwsn\07-App\heli\; ..\..\..\openwsn\07-App\imu\; ..\..\..\openwsn\07-App\layerdebug\; ..\..\..\openwsn\07-App\r6t\; ..\..\..\openwsn\07-App\rleds\; ..\..\..\openwsn\07-App\rreg\; ..\..\..\openwsn\07-App\rwellknown\; ..\..\..\openwsn\07-App\rt\; ..\..\..\openwsn\07-App\rex\; ..\..\..\openwsn\07-App\rrt\; ..\..\..\openwsn\07-App\rinfo\; ..\..\..\openwsn\07-App\rheli\; ..\..\..\openwsn\07-App\rxl1\; ..\..\..\openwsn\07-App\rrube\; ..\..\..\openwsn\07-App\ohlone\; ..\..\..\openwsn\07-App\tcpecho\; ..\..\..\openwsn\07-App\tcpinject\; ..\..\..\openwsn\07-App\tcpprint\; ..\..\..\openwsn\07-App\udpecho\; ..\..\..\openwsn\07-App\udpinject\; ..\..\..\openwsn\07-App\udplatency\; ..\..\..\openwsn\07-App\udpprint\; ..\..\..\openwsn\07-App\udprand\; ..\..\..\openwsn\07-App\udpstorm\; ..\..\..\openwsn\cross-layers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 03oos_macpong.srec
  ILINK.IlinkOutputFile: 03oos_macpong.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\boards\agilefox\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/03oos_macpong/: 03oos_macpong.c 03oos_macpong.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h sctimer.h uart.h
  group bsp/boards/agilefox
    ../../../bsp/boards/agilefox/: board.c board_info.h bsp_timer.c debugpins.c eui64.c gpio.c gpio.h leds.c nvic.c nvic.h radiotimer.c rcc.c rcc.h spi.c uart.c
  group bsp/boards/agilefox/configure
    ../../../bsp/boards/agilefox/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/agilefox/ewarm
    ../../../bsp/boards/agilefox/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/agilefox/lib
    ../../../bsp/boards/agilefox/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../../openwsn/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openwsn/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openwsn/02b-MAChigh
    ../../../openwsn/02b-MAChigh/: neighbors.c neighbors.h otf.c otf.h sixtop.c sixtop.h processIE.c processIE.h schedule.c schedule.h
  group openwsn/cross-layers
    ../../../openwsn/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
