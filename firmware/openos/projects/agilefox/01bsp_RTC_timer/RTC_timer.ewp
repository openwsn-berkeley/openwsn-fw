# IAR project RTC_timer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\stm32\configure\; ..\..\..\bsp\boards\stm32\library\inc\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\openwsn\OpenwsnHeads\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_timer.hex
  ILINK.IlinkOutputFile: RTC_timer.out
  ILINK.IlinkIcfFile: F:\TestForSTM32\bsp\boards\stm32\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../bsp/chip/at86rf231/: radio.c
  group application
    ../../../bsp/boards/: board_info.h bsp_timer.h debugpins.h exi.h gpio.h leds.h radio.h radiotimer.h sctimer.h spi.h Systick.h uart.h
    ../../../bsp/boards/stm32/: bsp_timer.c debugpins.c exi.c gpio.c leds.c radiotimer.c spi.c Systick.c uart.c
    ../../common/RTCtimer_test/: RTCtimer_test.c
  group stm32/config
    ../../../bsp/boards/stm32/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group stm32/ewarm
    ../../../bsp/boards/stm32/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group stm32/lib
    ../../../bsp/boards/stm32/library/src/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
