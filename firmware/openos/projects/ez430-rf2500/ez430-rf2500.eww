<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\01bsp_bothtimers\01bsp_bothtimers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_bothtimers_alt\01bsp_bothtimers_alt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_bsp_timer\01bsp_bsp_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_bsp_timer_alt\01bsp_bsp_timer_alt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_closetimers\01bsp_closetimers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_closetimers_alt\01bsp_closetimers_alt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_debugpins\01bsp_debugpins.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_leds\01bsp_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_radiotimer\01bsp_radiotimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_radiotimer_alt\01bsp_radiotimer_alt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_spi\01bsp_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\01bsp_uart\01bsp_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\02drv_opentimers\02drv_opentimers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\02drv_opentimers_alt\02drv_opentimers_alt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


