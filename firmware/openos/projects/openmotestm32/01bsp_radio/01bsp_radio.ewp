# IAR project 01bsp_radio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\bsp\boards\openmotestm\configure\; ..\..\..\bsp\boards\openmotestm\library\inc\; ..\..\..\bsp\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\openmotestm\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\kernel\; ..\..\..\drivers\common\; ..\..\..\openwsn\OpenwsnHeads\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 01bsp_radio.hex
  ILINK.IlinkOutputFile: 01bsp_radio.out
  ILINK.IlinkIcfFile: ..\..\..\bsp\boards\openmotestm\ewarm\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../common/01bsp_radio/: 01bsp_radio.c
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radiotimer.h uart.h
    ../../../bsp/boards/openmotestm/: board_info.h nvic.h rcc.h
  group bsp/boards/stm32
    ../../../bsp/boards/openmotestm/: board.c bsp_timer.c debugpins.c eui64.c leds.c nvic.c radiotimer.c rcc.c rtc_timer.c spi.c uart.c
  group bsp/boards/stm32/config
    ../../../bsp/boards/openmotestm/configure/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp/boards/stm32/ewarm
    ../../../bsp/boards/openmotestm/ewarm/: cortexm3_macro.s stm32f10x_vector.c
  group bsp/boards/stm32/lib
    ../../../bsp/boards/openmotestm/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp/chips
    ../../../bsp/chips/: spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
