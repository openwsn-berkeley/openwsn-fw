# IAR project test_gyro.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 200
  General.GHeapSize2: 200
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISR_I2C
  ICC430.newCCIncludePaths: ..\..\drivers\telosb; ..\..\openwsn; ..\..\openwsn\02a-MAC; ..\..\openwsn\cross-layers
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ./: test_gyro.c
  group drivers
    ../../drivers/telosb/: gyro.c i2c.c leds.c scheduler.c
    ../../openwsn/: openwsn.h
